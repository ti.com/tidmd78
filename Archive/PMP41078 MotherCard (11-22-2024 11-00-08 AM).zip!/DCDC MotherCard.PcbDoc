# Altium PCB DCDC MotherCard.PcbDoc (part 2 of 4)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 252.5 x 130 mm, 6 copper layers (Top Layer, Layer 2, Layer 3, Layer 4, Layer 5, Bottom Layer), stack 1.582 mm thick; 307 components, 181 nets, 1046 pads, 1409 vias.
Unrouted connection lines stored in the file: 2.

## Part data (continued)
C51 C69 C70 C71 C81 C82 C85 C100 C104 C107 C108: library part CMP-0006357-2, "CAP, CERM, 2200 pF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-4914-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=2200pF
C73 C86 C97: library part CMP-0006324-2, "CAP, CERM, 0.01 uF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402", Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-6893-1-ND, TempCo=X7R, Tolerance_%=10%, Value1="0.333065 ohm", Value2=50V, ValueDisplayed=0.01uF
D1: library part CMP-0002842-2, "LED, Red, SMD", Color=red, Manufacturer=Lite-On, Power_TotalModule=62.5mW, Value1=0.0625W, Value2=2V
D2: library part CMP-0002827-3, "LED, Green, SMD", Color=green, Manufacturer=Lite-On, Power_TotalModule=100mW, Value1=0.1W, Value2=2.1V
D3: library part CMP-0005919-2, "Diode, TVS, Bi, 24 V, SOT-23", Manufacturer="ON Semiconductor", Power_W=350mW, Supplier Part Number 1=NUP2105LT1GOSCT-ND, Value1=0.35W
D4 D5: library part CMP-0028855-2, "Diode, Schottky, 40 V, 3 A, AEC-Q101, SMAF", Manufacturer="Fairchild Semiconductor", Value1=3A, Value2=0.5V
D6 D7 D8 D9: library part CMP-0094495-1, "Diode Schottky 30 V 1A Surface Mount SOD-123", Digikey Part Number=MBR130T3GOSCT-ND, Forward Current=1A, Manufacturer=onsemi, Max Surge Forward Current=5.5A, Mouser Part Number=863-MBR130T3G, Operating Temperature Range="-65°C to +125°C", Peak Reverse Current=60uA
D10: library part CMP-0005910-2, "Diode, Zener, 4.7 V, 150 mW, AEC-Q101, SOD-523", Manufacturer=Rohm, Power_W=150mW, Supplier Part Number 1=78Y8306, Value1=0.15W
J1 J2 J5: library part CMP-0078462-1, "Receptacle, 1.27mm, 5x1, Gold with Tin tail, SMT", Color=Black, Current_A=1A, Manufacturer=Harwin, Supplier Part Number 1=952-3593-ND, Voltage_V=500V
J3 J4: library part CMP-0055125-1, "TERMINAL SCREW PC 30AMP, TH", Manufacturer=Keystone, Supplier Part Number 1=36-8199-ND
J6 J17: library part CMP-0075566-1, "Receptacle, 1.27mm, 7x2, Gold, SMT", Manufacturer=Samtec, Supplier Part Number 1=SAM1226-07-ND
J7 J11 J13: library part CMP-0055704-1, "Receptacle, 1.27mm, 3x2, Gold, SMT", Color=Black, Current_A=3.3A, Manufacturer=Samtec, Supplier Part Number 1=SAM1154-03-ND, Voltage_V=240V
J8: library part CMP-0003814-2, "C2000 controlCARD-120HSEC connector, SMT", Manufacturer=Samtec
J9: library part CMP-0003859-2, "C2000 controlCARD-180HSEC (60-pin addon) connector, SMT", Manufacturer=Samtec
J10: library part CMP-0074955-1, "CONN DB9 FEMALE R/A SOLDER TH", Manufacturer=NorComp, Supplier Part Number 1=182-909FE-ND
J12 J20: library part CMP-0075577-1, "Receptacle, 1.27mm, 6x2, Gold, SMT", Current_A=2A, Manufacturer=Samtec, Supplier Part Number 1=99P6807
J14 J15 J16: library part CMP-0055255-2, "MMCX JACK, 50 Ohm, Gold, TH", Color=Gold, Manufacturer=Molex, Supplier Part Number 1=WM5557-ND
J18: library part CMP-0054624-1, "Header, 2.54mm, 5x1, Gold, R/A, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", Supplier Part Number 1=S1111EC-05-ND
L1: library part CMP-0003317-1, "Ferrite Bead, 600 ohm @ 100 MHz, 0.5 A, 0402", Manufacturer=MuRata, Supplier Part Number 1=490-5441-1-ND, Value1="0.34 ohm", Value2=0.5A, ValueDisplayed="600 ohm"
L2: library part CMP-0062430-2, "Inductor, Ferrite, 100 uH, 0.15 A, 2 ohm, SMD", Manufacturer=TDK, Supplier Part Number 1=445-3959-1-ND, Value1="2 ohm", Value2=0.15A, ValueDisplayed=100uH
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll", Manufacturer=Brady, Supplier Part Number 1=97C5133
Logo1: library part CMP-0074844-1
LOGO2: library part CMP-0074835-1, "IEC 61010-1 High Voltage Warning"
Logo3: library part CMP-0074847-1, "FCC_disclaimer"
Logo4: library part CMP-0074769-1
LOGO5 LOGO6: library part CMP-0074837-1, "IEC 61010-1 Hot Surface Warning"
R1 R15 R16 R19 R26 R117 R118 R120 R121 R122 R123 R124 R126 R127 R128 R129 R132 R133: library part CMP-0080698-1, "RES, 0, 0%, 1 W, AEC-Q200 Grade 0, 2512", Manufacturer=Kamaya, Power_W=1W, Supplier Part Number 1=791-RMC1JPTE, Tolerance_%=0%, Value_Code=0
R2 R3: library part CMP-0018576-3, "RES, 10 k, 5%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-10KECT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.25W, Value_Code=10k0, ValueDisplayed=10k
R4 R5 R6 R7: library part CMP-0018574-3, "RES, 100 k, 5%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-100KECT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.25W, Value_Code=100k
R8 R9 R54 R78: library part CMP-0026786-1, "RES, 7.50 k, 0.1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, Power_W=63mW, Supplier Part Number 1=P7.5KDCCT-ND, TempCo="25 ppm/C", Tolerance_%=0.1%, Value2=0.063W, Value_Code=7k50, ValueDisplayed=7.50k
R10 R12 R13 R41 R46 R48 R49 R51 R63 R64 R68 R70 R71 R80 R98 R107: library part CMP-0026822-3, "RES, 0, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-0.0JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=0000, ValueDisplayed=0
R11 R17 R22: library part CMP-0023343-3, "RES, 0, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer="Stackpole Electronics Inc", Power_W=100mW, Supplier Part Number 1=RMCF0603ZT0R00CT-ND, TempCo=ppm/C, Tolerance_%=1%, Value2=0.1W, Value_Code=0
R14 R50 R60 R61 R65 R66 R79 R97 R99 R100 R103 R130 R134 R135 R136 R137: library part CMP-0026748-1, "RES, 10.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer="KOA Speer", Power_W=63mW, Supplier Part Number 1=660-RK73H1ETTP1002F, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=10k0, ValueDisplayed=10.0k
R18 R21: library part CMP-0022532-4, "RES, 60.4 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-60.4KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=60k4, ValueDisplayed=60.4k
R20 R33 R77 R119: library part CMP-0093609-1, "0Ω ±0 0.25W 1206 Thick Film Chip Resistor AEC-Q200 compliant", Manufacturer="Stackpole Electronics", Operating Temperature Range="-55°C to +155°C", Power_W=250mW
R23: library part CMP-0022138-4, "RES, 1.00 M, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-1.00MHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=1M00, ValueDisplayed=1.00M
R24 R32 R101 R102: library part CMP-0026676-1, "RES, 2.00 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P2.00KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=2k00, ValueDisplayed=2.00k
R25 R31 R67 R87 R96 R114: library part CMP-0026071-3, "RES, 1.00 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.00KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k00, ValueDisplayed=1.00k
R27 R40 R47 R52 R62 R73 R74 R76 R112 R113: library part CMP-0026764-1, "RES, 10.0, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer="Stackpole Electronics Inc", Power_W=63mW, Supplier Part Number 1=RMCF0402JT10R0CT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=10R0, ValueDisplayed=10.0
R28 R29 R39: library part CMP-0016648-3, "RES, 15.0, 1%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-15.0FCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.25W, Value_Code=15R0, ValueDisplayed=15.0
R30 R37 R38: library part CMP-0022268-4, "RES, 2.00 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-2.00KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=2k00, ValueDisplayed=2.00k
R34 R35 R36 R110 R115 R125 R131: library part CMP-0025951-3, "RES, 100, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-100LCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=100R, ValueDisplayed=100
R42: library part CMP-0026395-2, "RES, 47.5 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-47.5KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=47k5, ValueDisplayed=47.5k
R43 R44 R45 R104 R105 R106: library part CMP-0017741-3, "RES, 845 k, 1%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Panasonic, Power_W=250mW, Supplier Part Number 1=P845KFCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.25W, Value_Code=845k
R56 R108: library part CMP-0017234-3, "RES, 9.09 k, 1%, 0.25 W, AEC-Q200 Grade 0, 1206", Manufacturer=Vishay-Dale, Power_W=250mW, Supplier Part Number 1=541-9.09KFCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.25W, Value_Code=9k09, ValueDisplayed=9.09k
R58 R59 R69 R75 R109 R116: library part CMP-0026027-3, "RES, 15.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-15.0KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=15k0, ValueDisplayed=15.0k
R81: library part CMP-0026404-2, "RES, 49.9, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-49.9LCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=49R9, ValueDisplayed=49.9
R91 R95: library part CMP-0026750-1, "RES, 3.30 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer="KOA Speer", Power_W=63mW, Supplier Part Number 1=660-RK73H1ETTP3301F, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=3k30, ValueDisplayed=3.30k
R92 R111: library part CMP-0026337-2, "RES, 3.65 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-3.65KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=3k65, ValueDisplayed=3.65k
R93: library part CMP-0078244-2, "RES, 30.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-30.0KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=30k0, ValueDisplayed=30.0k
R94: library part CMP-0025950-3, "RES, 100 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-100KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=100k
T1: library part CMP-0085494-1, "Current Sense Transformer, 8.5 mH, 254 Vµs, 40 A, AEC-Q200 Grade 1, SMT", Manufacturer=Coilcraft, ValueDisplayed=8.5mH
TP3 TP4: library part CMP-0003719-1, "Testpoint", Manufacturer="Texas Instruments"
U1 U2: library part CMP-0860825-3, "5-V, Bidirectional 8:1, 1-Channel and 4:1, 2-Channel Multiplexers with Current Injection Control, DYY0016A (SOT-23-THIN-16)", Alternate Manufacturer="Texas Instruments"
U3: library part CMP-0089855-1, "Low-Power Fault Protected CAN FD Transceiver with INH and WAKE", Manufacturer="Texas Instruments", Max Supply Voltage=28V, Min Supply Voltage=1.7V, Operating Temperature Range="-40°C to +125°C"
U4: library part CMP-0051573-2, "Automotive Catalog Single 2-Input Positive-AND Gate, DBV0005A (SOT-23-5)", F @ Nom Voltage(Max)(Mhz)=75, Generic Part Number=SN74AHC1G08-Q1, ICC @ Nom Voltage(Max)(mA)=0.01, Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 125 C", Rating=Automotive, tpd @ Nom Voltage(Max)(ns)=12.3,7.9, Voltage(Nom)(V)=3.3,5
U5: library part CMP-0121215-2, "Automotive 50-MHz single-supply operational amplifier with rail-to-rail input and output 5-SOT-23 -40 to 125", Digikey Part Number=296-TLV365QDBVRQ1CT-ND, Input Bias Current=0.000005uA, Input Offset Voltage=0.4mV, Manufacturer="Texas Instruments", Max Supply Voltage=5.5V, Min Supply Voltage=2.2V, Mouser Part Number=595-TLV365QDBVRQ1, Nominal Supply Current=4.6mA, Operating Temperature Range="-40°C to +125°C", Output Current Per Channel=85mA, Voltage Gain=120dB
U6: library part CMP-0097985-1, Manufacturer="Texas Instruments", Operating Temperature Range=to
U7: library part CMP-0121413-1, "AEC-Q100, -5-V to 110-V, bidirectional, 1.1-MHz 8-V/µs ultraprecise current sense amplifier", Digikey Part Number=296-INA296A4QDDFRQ1TR-ND, Input Bias Current=35uA, Input Offset Voltage=0.003mV, Manufacturer="Texas Instruments", Max Supply Voltage=20V, Min Supply Voltage=2.7V, Mouser Part Number=595-INA296A4QDDFRQ1, Nominal Supply Current=2.5mA, Operating Temperature Range="-40°C to +125°C", Voltage Gain=0.1V/mV
U9: library part CMP-0121212-1, "Automotive, 0 to 2-V input, precision reinforced isolated amplifier with integrated DC/DC converter 16-SOIC -40 to 125", Digikey Part Number=296-AMC3311QDWERQ1CT-ND, Input Bias Current=0.0035uA, Input Offset Voltage=0.1mV, Manufacturer="Texas Instruments", Max Supply Voltage=5.5V, Min Supply Voltage=3V, Mouser Part Number=595-AMC3311QDWERQ1, Nominal Supply Current=28.5-36.5mA, Operating Temperature Range="-40°C to +125°C", Output Current Per Channel=14mA, Voltage Gain=0.001V/mV
U10: library part CMP-0065433-2, "Automotive, 36-V Prog. Gain, Bi-Directional, Zero-Drift, High-Speed Voltage Out Current Sense Amp, DGK0008A (VSSOP-8)", Alternate Manufacturer="Texas Instruments"
U11 U13: library part CMP-0120546-1, "Automotive, single-channel, 5.5-V 1-MHz rail-to-rail input and output operational amplifier 5-SOT-23 -40 to 125", Digikey Part Number=296-TLV9001QDBVRQ1CT-ND, Input Bias Current=0.000005uA, Input Offset Voltage=0.4mV, Manufacturer="Texas Instruments", Max Dual Supply Voltage=2.75V, Max Supply Voltage=5.5V, Min Dual Supply Voltage=900mV, Min Supply Voltage=1.8V, Mouser Part Number=595-TLV9001QDBVRQ1, Nominal Supply Current=60uA, Operating Temperature Range="-40°C to +125°C", Output Current Per Channel=40mA, Voltage Gain=130dB
U12: library part CMP-0090465-1, "Automotive 2-V input, reinforced isolated amplifier with high CMTI for voltage sensing 8-SOIC -40 to 125", Digikey Part Number=296-50938-1-ND, Input Bias Current=0.0035uA, Input Offset Voltage=-1.1mV, Manufacturer="Texas Instruments", Max Supply Voltage=5.5V, Min Supply Voltage=3V, Mouser Part Number=595-AMC1311BQDWVRQ1, Nominal Supply Current=5.3-7.1mA, Operating Temperature Range="-40°C to +125°C", Output Current Per Channel=13mA
U14: library part CMP-0054481-1, "Automotive Catalog Quadruple 2-Input Positive-AND Gate, PW0014A, LARGE T&R", F @ Nom Voltage(Max)(Mhz)=110, Generic Part Number=SN74AHC08Q-Q1, ICC @ Nom Voltage(Max)(mA)=0.02, Manufacturer="Texas Instruments", Operating Temperature Range(C)="-40 to 125", Rating=Automotive, tpd @ Nom Voltage(Max)(ns)=14,9, Voltage(Nom)(V)=3.3,5
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Free pads (board coordinates)
  round 7 hole 3.2: 1(-0.2,4.75) 1(0.175,125.325) 1(243.05,4.7) 1(243.15,125.725)
  round 4 hole 2.4: 1(55.525,36.2) 1(105.403,100.312)
  round 6 hole 3.2: 1(75.75,5.175) 1(78.75,105.175) 1(152.95,5.175) 1(155.95,105.175)
  round 5 hole 3.2: 1(102.825,16.9) 1(102.825,75.434)
  round 15 hole 8: 1(228.15,22.975) 1(228.15,87.475)
  rrect50% 6x18 hole 3 square: 2(136.7,22.975) 2(136.725,87.475)
  round 0.7 hole 0.7: 3(57.665,49.105) 3(57.665,50.375) 3(57.673,105.6) 3(57.673,106.87) 3(57.689,3.575) 3(57.689,4.795) 3(57.689,6.065) 3(57.689,7.335) 3(57.689,8.605) 3(57.689,9.875) 3(57.689,60.025) 3(57.689,61.295) 3(57.689,62.565) 3(57.689,63.835) 3(57.689,65.105) 3(57.689,66.375) 3(58.886,49.105) 3(58.886,50.375) 3(58.894,105.6) 3(58.894,106.87) 3(58.91,3.575) 3(58.91,4.795) 3(58.91,6.065) 3(58.91,7.335) 3(58.91,8.605) 3(58.91,9.875) 3(58.91,60.025) 3(58.91,61.295) 3(58.91,62.565) 3(58.91,63.835) 3(58.91,65.105) 3(58.91,66.375) 3(101.665,120.125) 3(102.935,120.125) 3(104.205,120.125) 3(105.475,120.125) 3(106.745,120.125) 3(108.015,120.125) 3(109.285,120.125) 3(117.01,120.075) 3(118.28,120.075) 3(119.55,120.075) 3(120.82,120.075) 3(122.09,120.075) 3(123.895,120.075) 3(125.165,120.075) 3(126.435,120.075) 3(127.705,120.075) 3(128.975,120.075) 3(130.78,120.075) 3(132.05,120.075) 3(133.09,98.885) 3(133.09,100.155) 3(133.09,101.425) 3(133.09,102.695) 3(133.09,103.965) 3(133.09,105.235) 3(133.09,106.505) 3(133.122,5.61) 3(133.122,6.88) 3(133.32,120.075) 3(134.341,98.885) 3(134.341,100.155) 3(134.341,101.425) 3(134.341,102.695) 3(134.341,103.965) 3(134.341,105.235) 3(134.341,106.505) 3(134.343,5.61) 3(134.343,6.88) 3(134.59,120.075) 3(135.86,120.075)

## Via types
v1: diameter 0.8, hole 0.5, Top Layer to Bottom Layer, 1180 vias
v2: diameter 0.6, hole 0.3, Top Layer to Bottom Layer, 227 vias
v3: diameter 4.5, hole 4.5, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3V3: C19.1 C22.1 C29.1 C42.1 C53.1 C75.1 C76.1 C82.1 C83.1 C88.1 C89.1 C96.1 C99.1 C105.1 C106.1 J8.119 L1.1 R8.2 R9.2 R14.2 R41.1 R42.1 R46.1 R50.2 R58.2 R78.2 R79.2 R103.2 R111.1 R130.2 U1.16 U2.16 U3.5 U4.5 U5.5 U7.6 U9.12 U10.3 U11.5 U12.8 U13.5 U14.14 | length 84.7
  Top Layer w0.254: U3.5@201.8,96.425 201.8,95.825 201.823,95.802 201.823,95.794 202.141,95.475 202.141,94.449 202.287,94.303 v2(202.866,94.303)
  Top Layer w0.5: U12.8@43.468,114.171 C96.1@45.381,114.171 45.219,114.332 v2(45.219,115.225) ; R9.2@110.649,3.523 110.686,3.56 R8.2@110.686,5.279 ; J8.119@177.754,62.006 180.444,62.006 v1(181.244,61.206) 182.815,61.206 R50.2@183.015,61.006
  Bottom Layer w0.254: v2(29.793,15.095) 29.793,16.663 29.807,16.677 ; L1.1@29.923,18.4 30.498,17.825 R111.1@31.3,17.825 ; R103.2@36.25,18.362 36.25,16.749 38.202,14.797 v2(40.124,14.797) ; v2(45.219,115.225) 46.655,115.225 47.493,114.387 47.493,109.216 47.363,109.086 R42.1@46.593,109.086 ; R46.1@112.052,66.06 111.496,66.06 111.147,65.711 111.147,62.462 111.387,62.222 R41.1@112.074,62.222 112.016,62.164 112.016,58.272 112.635,57.653 v2@115.163,57.653 ; C105.1@114.212,46.346 v2@115.135,46.346 ; U2.16@115.087,45.269 115.087,46.298 v2@115.135,46.346 ; v2@115.185,46.396 v2@115.135,46.346 ; U5.5@116.209,87.588 117.61,87.588 C29.1@117.708,87.685 ; v2(117.097,74.484) 117.182,74.484 117.794,73.872 117.794,73.113 C88.1@117.864,73.043 ; U7.6@117.269,15.632 118.378,15.632 C42.1@118.743,15.267 ; U4.5@117.947,30.493 118.041,30.399 C19.1@118.041,28.865 119.409,28.865 v2(120.723,27.55) ; U14.14@119.377,21.533 119.377,19.9 C89.1@119.389,19.889 v2(120.429,19.889)
  Bottom Layer w0.4: C53.1@116.209,57.672 116.268,57.731 116.268,58.631 116.473,58.836 U10.3@116.473,59.769
  Bottom Layer w0.5: R79.2@28.43,19.994 28.43,18.4 C76.1@28.395,18.365 ; C75.1@28.631,16.925 28.631,18.129 C76.1@28.395,18.365 ; 29.807,16.677 29.807,18.284 L1.1@29.888,18.365 ; L1.1@29.923,18.4 L1.1@29.888,18.365 ; U9.12@42.218,111.626 C82.1@45.4,111.626 45.238,111.788 C83.1@45.238,112.896 45.238,115.206 v2(45.219,115.225) ; 115.157,54.572 115.163,54.577 115.163,57.653 116.19,57.653 C53.1@116.209,57.672 ; U11.5@116.205,80.297 v2(116.977,80.297) 117.18,80.094 C99.1@117.944,80.094 ; U13.5@116.282,73.043 C88.1@117.864,73.043 ; R78.2@118.339,66.178 v2(119.569,66.178) ; R130.2@120.96,51.606 120.964,51.601 v2(120.964,50.836) ; v2(122.175,45.499) 122.175,44.795 R14.2@122.185,44.785 ; C76.1@28.395,18.365 L1.1@29.888,18.365
  other v2: 110.686,4.42 118.223,15.632 113.095,17.53 115.111,46.322 115.111,57.837 116.909,87.588
5V0: J2.5 J8.48 J8.84 J8.98 J8.112 J9.158 J9.180 J12.2 J17.4 J20.2 R80.2 | length 422.5
  Top Layer w0.254: v2(195.943,59.888) 195.943,92.519 197.762,94.338 R80.2@198.338,94.338
  Top Layer w0.5: J8.48@174.354,30.006 175.508,30.006 175.596,30.094 J8.84@175.596,47.606 ; J8.84@174.354,47.606 J8.84@175.596,47.606 ; J8.98@174.354,53.206 J8.98@175.596,53.206 ; J8.112@174.354,58.806 v2(175.596,58.806) J8.98@175.596,53.206 ; J9.158@174.354,97.363 175.647,97.363 v2(175.647,106.163) J9.180@174.354,106.163 ; J8.84@175.596,47.606 J8.98@175.596,53.206
  Layer 2 w0.5: v2(175.596,58.806) 173.139,61.263 173.139,93.797 175.647,96.306 v2(175.647,106.163)
  Layer 3 w0.5: v2(56.457,3.525) 55.1,3.525 54.375,4.25 54.375,12.396 55.804,13.825 75.642,13.825 94.243,32.427 94.243,58.855 ; v2(56.457,60.025) 56.457,59.413 57.016,58.855 94.243,58.855 ; v2(123.895,121.425) 123.06,120.59 123.06,115.575 ; v2(131.875,100.155) 123.06,100.155 ; v2(175.596,58.806) 194.86,58.806 v2(195.943,59.888) ; v2(175.647,106.163) 173.693,106.163 164.282,115.575 123.06,115.575 ; 94.243,58.855 107.069,58.855 123.06,74.846 123.06,100.155 ; 123.06,100.155 123.06,115.575
5V0_CAN: J8.117 R10.2 | length 55.5
  Top Layer w0.254: v2(196.735,61.325) 196.735,92.325 197.514,93.103 R10.2@198.338,93.103
  Top Layer w0.5: v2(176.412,61.206) J8.117@177.754,61.206
  Layer 3 w0.5: v2(176.412,61.206) 177.552,62.346 195.715,62.346 v2(196.735,61.325)
12V: 12V.1 J2.1 J17.3 | length 136.2
  Layer 3 w1: 12V.1@41.438,128 42.773,128 45.219,125.553 45.219,120.201 47.2,118.22 51.17,118.22 58.451,125.501 69.2,125.501 126.375,125.475 128.975,122.875 v2(128.975,121.425)
  Bottom Layer w0.5: v2(128.975,121.425) 128.975,122.691 129.809,123.525 137.725,123.525 138.311,122.939 138.311,101.425 137.041,100.155 v2(135.56,100.155)
A0: J8.85 R134.2 U2.10 | length 88.2
  Top Layer w0.254: J8.85@177.754,48.406 184.244,48.406 v2(185.044,49.206)
  Layer 3 w0.254: v2(113.519,41.075) 115.844,38.75 157.725,38.75 168.181,49.206 v2(185.044,49.206)
  Bottom Layer w0.254: R134.2@112.131,40.956 112.25,41.075 v2(113.519,41.075) 113.928,41.484 113.928,41.86 114.337,42.269 U2.10@115.087,42.269
A1: J8.87 R135.2 U2.9 | length 86.3
  Top Layer w0.254: J8.87@177.754,49.206 183.427,49.206 v2(184.47,50.249)
  Layer 3 w0.254: v2(115.087,41.075) 116.78,39.382 157.407,39.382 167.931,49.906 184.128,49.906 v2(184.47,50.249)
  Bottom Layer w0.254: R135.2@112.131,39.725 114.332,39.725 115.087,40.48 v2(115.087,41.075) U2.9@115.087,41.769
A2: J8.104 R136.2 U1.10 | length 69.1
  Top Layer w0.254: v2(170.598,55.606) J8.104@174.354,55.606
  Layer 3 w0.254: v2(113.932,50.332) 116.962,47.302 123.375,47.302 124.851,45.826 158.87,45.826 168.65,55.606 v2(170.598,55.606)
  Bottom Layer w0.254: R136.2@113.932,49.604 v2(113.932,50.332) 113.932,51.059 114.243,51.369 U1.10@115.139,51.369
A3: J8.106 R137.2 U1.9 | length 65.9
  Top Layer w0.254: v2(171.567,56.406) J8.106@174.354,56.406
  Layer 3 w0.254: v2(115.139,50.346) 117.487,47.998 123.586,47.998 124.721,46.863 158.963,46.863 168.506,56.406 v2(171.567,56.406)
  Bottom Layer w0.254: U1.9@115.139,50.869 v2(115.139,50.346) 115.139,49.623 R137.2@115.157,49.604
ACL1_PWM: J8.58 J17.1 | length 82.4
  Top Layer w0.254: v2(166.986,41.167) 170.948,37.206 J8.58@174.354,37.206
  Layer 2 w0.254: v2(135.56,98.885) 140.165,98.885 161.467,77.583 161.467,46.686 v2(166.986,41.167)
ACL2_PWM: J8.60 J17.2 | length 86
  Top Layer w0.254: v2(169.308,40.126) 171.429,38.006 J8.60@174.354,38.006
  Layer 2 w0.254: v2(131.875,98.885) 132.865,97.895 140.105,97.895 160.6,77.4 160.6,46.217 166.691,40.126 v2(169.308,40.126)
AGND: AGND.1 BIAS_DGND.1 C19.2 C20.2 C21.2 C22.2 C23.2 C29.2 C30.2 C35.2 C42.2 C51.2 C52.2 C53.2 C54.2 C69.2 C70.2 C71.2 C73.2 C75.2 C76.2 C77.2 C78.2 C82.2 C83.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C96.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 D2.2 D3.3 J1.1 J1.2 J2.2 J2.3 J2.4 J5.5 J8.7 J8.10 J8.13 J8.16 J8.19 J8.22 J8.35 J8.38 J8.46 J8.47 J8.65 J8.83 J8.97 J8.111 J9.135 J9.157 J9.179 J10.3 J10.6 J12.4 J12.6 J14.2 J14.3 J14.4 J14.5 J15.2 J15.3 J15.4 J15.5 J16.2 J16.3 J16.4 J16.5 J17.5 J17.6 J18.5 J20.4 J20.6 pad.1@102.825,16.9 pad.1@102.825,75.434 R11.2 R23.1 R32.1 R48.2 R49.1 R54.1 R69.1 R75.1 R87.1 R94.1 R96.1 R101.1 R102.1 R114.1 R116.1 R134.1 R135.1 R136.1 R137.1 TP4.1 U1.6 U1.8 U2.6 U2.8 U3.2 U4.3 U5.2 U6.3 U7.2 U9.9 U9.15 U10.2 U11.2 U12.5 U13.2 U14.7 | length 100.6
  Top Layer w0.254: 199.925,95.325 200.3,95.7 U3.2@200.3,96.425
  Top Layer w0.5: J8.10@174.354,14.806 176.054,14.806 ; J8.16@174.354,17.206 176.054,17.206 ; J8.22@174.354,19.606 176.054,19.606 ; J8.38@174.354,26.006 176.054,26.006 ; J8.46@174.354,29.206 176.054,29.206 ; 176.054,14.006 J8.7@177.754,14.006 ; 176.054,14.123 176.054,14.806 ; J8.13@177.754,16.406 176.054,16.406 ; J8.19@177.754,18.806 176.054,18.806 ; J8.35@177.754,25.206 176.054,25.206 ; J8.47@177.754,30.006 176.6,30.006 176.6,29.206 176.054,29.206 ; J8.65@177.754,40.406 176.522,40.406 J8.83@176.522,47.606 ; J8.83@177.754,47.606 J8.83@176.522,47.606 ; J8.97@177.754,53.206 176.649,53.206 J8.97@176.522,53.079 ; J8.111@177.754,58.806 176.522,58.806 J8.97@176.522,53.079 ; J9.135@177.754,88.563 176.624,88.563 176.6,88.587 J9.157@176.6,97.363 ; J9.157@177.754,97.363 J9.157@176.6,97.363 ; J9.179@177.754,106.163 176.6,106.163 J9.157@176.6,97.363 ; 176.054,14.806 176.054,16.406 ; 176.054,16.406 176.054,17.206 ; 176.054,17.206 176.054,18.806 ; 176.054,18.806 176.054,19.606 ; 176.054,19.606 176.054,25.206 ; 176.054,25.206 176.054,26.006 ; 176.054,26.006 176.054,29.206 ; J8.83@176.522,47.606 J8.97@176.522,53.079
  Bottom Layer w0.254: C102.2@115.16,74.993 R116.1@115.16,76.211 115.255,76.306 U11.2@115.255,77.697 ; U2.6@118.087,42.769 118.612,42.769 118.635,42.746 118.718,42.746 118.904,42.56 119.049,42.415 119.049,42.351 ; U1.6@118.139,51.869 119.029,51.869
  Bottom Layer w0.5: U6.3@38.813,21.925 38.813,20.712 38.931,20.594 38.931,19.6 ; U9.15@42.218,107.816 42.228,107.826 v2(43.619,107.826) ; U9.9@42.218,115.436 v2(43.468,115.436) ; C78.2@46.593,110.356 46.593,111.619 C82.2@46.6,111.626 46.762,111.788 C83.2@46.762,112.896 v2(46.762,113.617) ; D3.3@202.225,114.375 205.184,114.375 C23.2@205.609,114.8 205.609,116.17 R23.1@206.309,116.87 204.524,118.655 J10.3@204.524,119.095
  other v2: 201.325,2.3 207.816,3.051 56.457,4.795 158.575,5.013 227.375,5.1 56.457,6.065 29.888,11.869 40.832,13.188 112.393,15.808 117.111,19.889 101.25,21.95 113.75,26.202 116.473,32.393 110.04,40.246 119.263,41.675 105.059,43.801 127.15,44.269 112.859,48.117 121.197,49.891 117.977,56.289 56.457,61.295 56.457,62.565 105.15,63.361 119.978,67.443 120.931,71.195 116.225,75.334 116.407,82.52 155.429,87.475 119.773,87.588 131.875,101.425 135.56,101.425 205.508,104.421 139.729,107.199 133.554,109.394 122.09,118.725 125.165,118.725 127.705,118.725 130.78,118.725 126.435,121.425 132.05,121.425
AGNDM: J6.11 J11.4 J11.6 pad.3@58.886,49.105 pad.3@58.886,50.375 R20.1 | length 8
  Bottom Layer w0.7: R20.1@107.075,115.15 107.075,116.27 108.015,117.21 ; J6.11@108.015,118.87 108.015,117.21 ; v2(110.901,114.743) 110.482,114.743 108.015,117.21
  other v2: 59.89,49.105 59.89,50.375
AGNDP: C41.2 C44.2 C79.2 C80.2 C81.2 C84.2 C85.2 C86.2 C95.2 C97.2 D10.2 J6.3 J7.4 J7.6 pad.3@58.894,105.6 pad.3@58.894,106.87 R20.2 R56.1 R108.1 R119.2 U9.2 U9.7 U9.8 U12.3 U12.4 | length 24.9
  Top Layer w0.7: C95.2@30.168,115.351 C95.2@30.188,115.371 ; C44.2@30.993,117.222 30.993,115.583 v2(31.04,115.536) ; 32.148,115.269 32.314,115.436 32.462,115.436 C41.2@32.462,117.06
  Bottom Layer w0.254: R56.1@25.618,110.181 25.783,110.016 C84.2@28.943,110.016 ; C79.2@27.843,107.791 C81.2@28.968,107.791 ; C85.2@30.118,110.016 C84.2@28.943,110.016 ; U9.2@32.468,107.816 32.406,107.878 C80.2@30.293,107.878 30.206,107.791 C81.2@28.968,107.791 ; U9.7@32.468,114.166 C86.2@30.168,114.166 30.168,114.664 v2(31.04,115.536) 31.14,115.436 U9.8@32.468,115.436 ; C84.2@28.943,110.016 v2(28.943,109.086) 28.943,107.816 C81.2@28.968,107.791
  Bottom Layer w0.7: J6.3@102.935,118.92 102.935,116.988 103.875,116.048 R20.2@103.875,115.15
  other v2: 59.905,105.6 59.905,106.87 102.47,116.166
BIAS_HS_12V: BIAS_HS_12V.1 D4.2
BIAS_VIN: BIAS_VIN.1 C52.1 D4.1 D5.1 J1.4 J1.5 R92.2 R97.2 U3.10 | length 200.6
  Top Layer w0.254: R97.2@161.95,112.645 v2(161.95,118.725) ; U3.10@201.8,99.425 201.8,101.933 C52.1@202.2,102.333 205.553,105.685 ; R92.2@206.496,103.453 206.496,104.742 205.553,105.685 ; v1(209.749,107.874) 208.19,106.315 206.183,106.315 205.553,105.685
  Top Layer w1: D4.1@49.465,119.325 49.5,119.36 v1(49.5,120.875) ; D5.1@209.36,109.833 D5.1@209.436,109.757 209.436,108.188 v1(209.749,107.874)
  Layer 3 w1: v1(49.5,120.875) 56.95,128.325 127.69,128.325 v2(134.59,121.425) 137.161,121.425 138.578,120.008 138.578,118.725 ; v2(135.86,118.725) 138.578,118.725 ; v1(209.749,107.874) 186.762,107.874 v2(183.191,111.445) 175.911,118.725 v2(161.95,118.725) 138.578,118.725
CAN_FLT: J8.79 U3.8 | length 74.8
  Top Layer w0.254: J8.79@177.754,46.006 181.055,46.006 181.63,46.58 188.415,46.58 192.209,50.373 192.209,96.85 193.472,98.113 202.173,98.113 202.8,98.741 U3.8@202.8,99.425
CAN_WAKE: R71.1 R93.1 | length 1.4
  Top Layer w0.254: R71.1@203.834,100.822 R93.1@205.261,100.822
CANH_BUS: D3.2 J10.7 L2.4 R21.1 R22.2 | length 23.7
  Top Layer w0.254: R22.2@197.479,107.546 R21.1@197.479,109.121 197.629,108.971 L2.4@199.479,108.971 199.479,110.704 200.402,111.627 200.402,119.832 202.505,121.935 J10.7@203.139,121.935
  Bottom Layer w0.254: J10.7@203.139,121.935 203.175,121.899 D3.2@203.175,116.775
CANL_BUS: D3.1 J10.2 L2.3 R17.2 R18.2 | length 16.3
  Top Layer w0.254: J10.2@201.754,119.095 201.706,119.048 201.706,111.007 201.979,110.734 L2.3@201.979,108.971 203.879,108.971 203.954,109.046 R17.2@203.954,107.496
  Bottom Layer w0.5: D3.1@201.275,116.775 201.275,118.617 J10.2@201.754,119.095
DAC1: J8.9
DAC2: J8.14
DEBUG1: J9.125 J18.3 | length 70.5
  Top Layer w0.254: J18.3@175.987,126.025 174.737,127.275 172.85,127.275 172.1,126.525 172.1,125.427 172.802,124.725 172.802,122.977 172.775,122.95 172.775,117.4 167.225,111.85 167.225,86.542 173.542,80.225 180.3,80.225 180.85,80.775 180.85,84.225 180.512,84.563 J9.125@177.754,84.563
DEBUG2: J9.126 J18.4 | length 48.8
  Top Layer w0.254: J18.4@173.447,126.025 173.447,117.047 167.975,111.575 167.975,86.75 170.162,84.563 J9.126@174.354,84.563
DGND: C2.2 C11.2 C12.2 C14.2 C15.2 C16.2 C17.2 C25.2 C26.2 C27.2 C28.2 C31.2 C32.2 C33.2 C34.2 C36.2 C37.2 C38.2 C39.2 C40.2 C43.2 C48.2 C49.2 C50.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 pad.1@0.175,125.325 pad.1@228.15,87.475 pad.1@243.05,4.7 pad.1@243.15,125.725 pad.1@-0.2,4.75 pad.2@136.725,87.475 R11.1 R33.2 R73.1 R74.1 R77.2 | length 217.9
  Top Layer w1: v1(216.764,97.96) R11.1@216.764,100.842
  Layer 3 w0.254: v2(122.915,60.703) 121.926,61.691 121.926,63.674 135.252,77 176.925,77 177.1,77.175 177.1,77.69 176.89,77.9 139.7,77.9 136.725,80.875 pad.2@136.725,87.475 ; v2(122.915,63.241) 135.823,76.15 215.328,76.15 v1(216.775,77.597)
  Bottom Layer w0.254: R73.1@121.805,60.672 122.884,60.672 v2(122.915,60.703) ; R74.1@121.808,63.211 121.839,63.241 v2(122.915,63.241)
  other v1: 209.05,44.952 218.5,44.952 242.95,44.952 207.3,45.782 210.75,45.782 216.75,45.782 220.2,45.782 241.2,45.782 244.65,45.782 207.3,48.026 210.75,48.026 216.75,48.026 220.2,48.026 241.2,48.026 244.65,48.026 209.05,48.907 218.5,48.907 242.95,48.907 134.564,50.471 135.664,50.471 158.672,50.684 146.527,50.717 147.627,50.717 134.564,51.353 135.664,51.353 158.672,51.566 146.527,51.599 147.627,51.599 146.527,53.79 147.627,53.79 134.564,53.999 135.664,53.999 158.672,54.212 146.527,54.672 147.627,54.672 134.564,54.881 135.664,54.881 158.672,55.094 146.527,56.891 147.627,56.891 134.614,57.071 135.714,57.071 158.722,57.284 146.527,57.773 147.627,57.773 134.614,57.953 135.714,57.953 158.722,58.166 134.564,60.172 135.664,60.172 146.477,60.185 147.577,60.185 158.672,60.385 134.564,61.054 135.664,61.054 146.477,61.067 147.577,61.067 158.672,61.267 209.05,62.125 218.5,62.125 242.95,62.125 207.3,62.954 216.75,62.954 220.2,62.954 241.2,62.954 244.65,62.954 207.3,65.198 210.75,65.198 216.75,65.198 220.2,65.198 241.2,65.198 244.65,65.198 209.05,66.079 218.5,66.079 242.95,66.079 220.661,76.284 221.935,76.284 223.208,76.284 224.636,76.284 225.91,76.284 227.183,76.284 228.611,76.284 229.885,76.284 231.158,76.284 232.636,76.284 233.91,76.284 235.183,76.284 236.586,76.284 237.86,76.284 239.133,76.284 240.686,76.284 241.959,76.284 243.232,76.284 216.775,76.294 218.048,76.294 219.322,76.294 218.048,77.597 219.322,77.597 220.661,77.587 221.935,77.587 223.208,77.587 224.636,77.587 225.91,77.587 227.183,77.587 228.611,77.587 229.885,77.587 231.158,77.587 232.636,77.587 233.91,77.587 235.183,77.587 236.586,77.587 237.86,77.587 239.133,77.587 240.686,77.587 241.959,77.587 243.232,77.587 216.775,78.9 218.048,78.9 219.322,78.9 220.661,78.89 221.935,78.89 223.208,78.89 224.636,78.89 225.91,78.89 227.183,78.89 228.611,78.89 229.885,78.89 231.158,78.89 232.636,78.89 233.91,78.89 235.183,78.89 236.586,78.89 237.86,78.89 239.133,78.89 240.686,78.89 241.959,78.89 243.232,78.89 216.816,80.247 218.09,80.247 219.363,80.247 236.575,80.247 237.848,80.247 239.122,80.247 240.649,80.247 241.923,80.247 243.196,80.247 216.816,81.55 218.09,81.55 219.363,81.55 236.575,81.55 237.848,81.55 239.122,81.55 240.649,81.55 241.923,81.55 243.196,81.55 216.75,82.969 218.023,82.969 219.297,82.969 236.6,82.969 237.873,82.969 239.147,82.969 240.674,82.969 241.948,82.969 243.221,82.969 216.75,84.272 218.023,84.272 219.297,84.272 236.6,84.272 237.873,84.272 239.147,84.272 240.674,84.272 241.948,84.272 243.221,84.272 216.75,85.575 218.023,85.575 219.297,85.575 236.6,85.575 237.873,85.575 239.147,85.575 240.674,85.575 241.948,85.575 243.221,85.575 216.75,87.119 218.023,87.119 219.297,87.119 236.575,87.119 237.848,87.119 239.122,87.119 240.649,87.119 241.923,87.119 243.196,87.119 216.75,88.422 218.023,88.422 219.297,88.422 236.575,88.422 237.848,88.422 239.122,88.422 240.649,88.422 241.923,88.422 243.196,88.422 216.75,89.725 218.023,89.725 219.297,89.725 236.575,89.725 237.848,89.725 239.122,89.725 240.649,89.725 241.923,89.725 243.196,89.725 216.711,91.294 217.985,91.294 219.258,91.294 236.6,91.294 237.873,91.294 239.147,91.294 240.674,91.294 241.948,91.294 243.221,91.294 216.711,92.597 217.985,92.597 219.258,92.597 236.6,92.597 237.873,92.597 239.147,92.597 240.674,92.597 241.948,92.597 243.221,92.597 216.711,93.9 217.985,93.9 219.258,93.9 236.6,93.9 237.873,93.9 239.147,93.9 240.674,93.9 241.948,93.9 243.221,93.9 216.764,95.353 218.037,95.353 219.311,95.353 220.65,95.344 221.923,95.344 223.197,95.344 224.625,95.344 225.898,95.344 227.172,95.344 228.6,95.344 229.873,95.344 231.147,95.344 232.625,95.344 233.898,95.344 235.172,95.344 236.575,95.344 237.848,95.344 239.122,95.344 240.674,95.344 241.948,95.344 243.221,95.344 216.764,96.657 218.037,96.657 219.311,96.657 220.65,96.647 221.923,96.647 223.197,96.647 224.625,96.647 225.898,96.647 227.172,96.647 228.6,96.647 229.873,96.647 231.147,96.647 232.625,96.647 233.898,96.647 235.172,96.647 236.575,96.647 237.848,96.647 239.122,96.647 240.674,96.647 241.948,96.647 243.221,96.647 220.65,97.95 221.923,97.95 223.197,97.95 224.625,97.95 225.898,97.95 227.172,97.95 228.6,97.95 229.873,97.95 231.147,97.95 232.625,97.95 233.898,97.95 235.172,97.95 236.575,97.95 237.848,97.95 239.122,97.95 240.674,97.95 241.948,97.95 243.221,97.95 218.037,97.96 219.311,97.96
  other v2: 85.194,3.965 85.832,3.965 85.194,5.175 85.832,5.179 85.194,6.065 85.832,6.065
EN_5V0: J5.4 J8.72 | length 115.7
  Top Layer w0.254: 167.545,46.844 167.545,46.024 168.244,45.325 169.202,45.325 171.721,42.806 J8.72@174.354,42.806
  Layer 2 w0.254: v2(120.82,121.425) 122.62,123.225 138.875,123.225 141.125,120.975 141.125,107.005 167.545,80.584 v2(167.545,47.145)
EN_12V: J5.3 J8.74 | length 111.1
  Top Layer w0.254: v2(168.437,46.24) 169.141,46.24 171.776,43.606 J8.74@174.354,43.606
  Layer 2 w0.254: v2(119.55,118.725) 120.55,117.725 138.4,117.725 140.5,115.625 140.5,106.751 165.996,81.256 165.996,47.129 166.884,46.24 v2(168.437,46.24)
EN_ACL: J8.70 J17.8 | length 105.8
  Top Layer w0.254: v2(131.875,102.695) 131.756,102.814 129.81,102.814 128.856,103.769 128.856,108.406 130.8,110.35 141.701,110.35 156.723,95.328 156.723,74.827 166.7,64.85 166.7,45.877 167.868,44.709 168.794,44.709 171.497,42.006 J8.70@174.354,42.006
EN_CAN: J8.77 U3.6 | length 74.5
  Top Layer w0.254: J8.77@177.754,45.206 181.172,45.206 182.019,46.052 188.712,46.052 192.725,50.065 192.725,96.509 193.777,97.562 202.132,97.562 202.3,97.394 U3.6@202.3,96.425
EN_SR: J8.68 J17.7 | length 85.3
  Top Layer w0.254: v2(167.655,42.774) 169.841,42.774 171.408,41.206 J8.68@174.354,41.206
  Layer 2 w0.254: v2(135.56,102.695) 143.655,102.695 165.204,81.146 165.204,45.225 v2(167.655,42.774)
ERRORSTS: J9.178 U14.9 U14.12 | length 147.2
  Top Layer w0.254: v2(120.546,24.605) 125.55,29.609 125.55,112.1 v2(126.575,113.125)
  Top Layer w0.5: v2(171.645,105.363) J9.178@174.354,105.363
  Layer 3 w0.254: v2(126.575,113.125) 165.524,113.125 171.645,107.004 v2(171.645,105.363)
  Bottom Layer w0.254: U14.12@119.377,22.833 120.398,22.833 120.723,23.158 120.723,24.428 v2(120.546,24.605) 120.368,24.783 U14.9@119.377,24.783
GaN_FAULT: C69.1 D1.2 J8.102 R34.2 | length 140.8
  Top Layer w0.254: v2(114.804,6.207) 114.804,5.373 D1.2@114.892,5.285 ; v2@171.436,54.936 v2(171.567,54.806) J8.102@174.354,54.806
  Layer 3 w0.254: v2(114.804,6.207) 115.676,7.079 115.676,34.331 v2(116.42,35.075) 107.956,43.539 107.956,54.169 110.807,57.02 123.254,57.02 126,54.274 126,50.273 127.967,48.306 158.231,48.306 169.531,59.606 172.223,59.606 172.98,58.848 172.98,55.205 172.581,54.806 v2(171.567,54.806)
  Bottom Layer w0.254: C69.1@114.912,34.224 R34.2@116.427,34.224 116.42,34.232 v2(116.42,35.075)
GaN_OC_1: C71.1 J8.94 R36.2 | length 58.3
  Top Layer w0.254: v2(171.41,51.566) 174.314,51.566 J8.94@174.354,51.606
  Layer 3 w0.254: v2(122.175,41.675) 156.825,41.675 166.716,51.566 v2(171.41,51.566)
  Bottom Layer w0.254: v2(122.175,41.675) C71.1@122.175,42.6 122.185,42.61 R36.2@122.185,43.71
GaN_OC_2: C108.1 J8.100 R131.2 | length 86.3
  Top Layer w0.254: v2(170.598,54.006) J8.100@174.354,54.006
  Layer 3 w0.254: v2(122.16,54.826) 113.167,54.826 111.728,53.387 111.728,51.267 118.212,44.784 119.192,44.784 121.516,42.46 156.405,42.46 167.951,54.006 v2(170.598,54.006)
  Bottom Layer w0.254: C108.1@122.16,52.772 R131.2@122.16,54.043 v2(122.16,54.826)
GS0: R46.2 R49.2 U10.5 | length 4
  Bottom Layer w0.254: R46.2@112.052,64.86 R49.2@113.258,64.86 114.265,64.86 114.906,64.219 U10.5@115.823,64.219
GS1: R41.2 R48.1 U10.6 | length 5.6
  Bottom Layer w0.254: R41.2@112.074,63.422 113.222,63.422 R48.1@113.301,63.502 114.69,63.502 115.248,62.944 115.97,62.944 116.473,63.446 U10.6@116.473,64.219
I_HV_1: C77.1 J8.11 J15.1 R40.2 | length 173.8
  Top Layer w0.254: J8.11@177.754,15.606 180.169,15.606 180.525,15.25 180.525,4.41 v2(179.675,3.56)
  Layer 4 w0.254: v2(37.753,6.457) 43.962,12.666 89.809,12.666 93.025,9.45 156.675,9.45 162.565,3.56 v2(179.675,3.56)
  Bottom Layer w0.254: C77.1@35.05,12.39 35.05,11.15 37.753,8.448 v2(37.753,6.457) J15.1@37.753,4.407
  Bottom Layer w0.5: R40.2@35.003,13.793 35.05,13.746 C77.1@35.05,12.39
I_HV_2: C30.1 J8.12 J14.1 R27.2 | length 153.5
  Top Layer w0.254: J14.1@118.784,4.407 118.784,9.328 118.754,9.358 ; v2(119.433,81.463) 115.888,81.463 107.177,72.752 107.177,14.569 112.388,9.358 118.754,9.358 ; J8.12@174.354,15.606 169.658,15.606 165.002,10.949 150.587,10.949 148.995,9.358 118.754,9.358
  Bottom Layer w0.254: R27.2@118.874,83.772 118.874,82.687 C30.1@118.854,82.668 119.433,82.089 v2(119.433,81.463)
I_HV_FAULT: C104.1 J8.110 R115.2 | length 170.8
  Top Layer w0.254: v2(171.567,58.006) J8.110@174.354,58.006
  Layer 2 w0.254: v2(38.586,15.925) 41.6,15.925 42.76,14.765 80.99,14.765 103.075,36.85 168.038,36.85 171.75,40.562 171.75,44.225 170.325,45.65 170.325,48.419 168.946,49.798 168.946,56.678 170.273,58.006 v2(171.567,58.006)
  Bottom Layer w0.254: R115.2@37.547,18.4 37.547,17.752 37.725,17.573 C104.1@37.725,16.925 37.725,16.28 38.08,15.925 v2(38.586,15.925)
I_HV_FILTER: C51.1 J8.28 R67.2 | length 124.3
  Top Layer w0.254: v2(124.825,21.675) 124.825,20.886 133.312,12.399 147.075,12.399 148.931,14.256 162.344,14.256 170.094,22.006 J8.28@174.354,22.006
  Layer 5 w0.254: v2@124.706,21.556 v2(124.825,21.675)
  Bottom Layer w0.254: C51.1@121.541,86.252 121.51,86.221 R67.2@121.51,84.878 121.51,83.795 v2(121.619,83.686) 125.3,80.005 125.3,22.15 v2(124.825,21.675)
I_HV_OC: C100.1 J8.108 R110.2 | length 177.8
  Top Layer w0.254: v2(170.598,57.206) J8.108@174.354,57.206
  Layer 2 w0.254: v2(33.68,9.781) 40.79,9.781 44.968,13.959 81.359,13.959 103.6,36.2 168.318,36.2 172.35,40.232 172.35,44.455 170.967,45.838 170.967,48.654 169.611,50.01 169.611,56.218 v2(170.598,57.206)
  Bottom Layer w0.254: C100.1@33.463,12.323 33.463,9.999 v2(33.68,9.781)
  Bottom Layer w0.5: C100.1@33.463,12.323 33.733,12.593 R110.2@33.733,13.793
I_LV_1: C94.1 J8.21 J16.1 R62.2 R91.2 | length 234.9
  Top Layer w0.254: J8.21@177.754,19.606 180.419,19.606 181.825,18.2 181.825,3.9 v2(182.165,3.56) ; R91.2@187.067,105.615 188.101,105.615 v2(188.125,105.639)
  Layer 2 w0.254: v2(182.165,3.56) 189.869,11.264 189.869,69.975 204.908,85.014 204.908,102.542 201.811,105.639 v2(188.125,105.639)
  Bottom Layer w0.254: R62.2@120.05,16.458 120.05,15.279 C94.1@120.091,15.238 123.814,15.238 128.823,10.229 139.43,10.229 ; J16.1@127.294,4.414 128.962,4.414 130.768,2.607 138.223,2.607 139.43,3.815 139.43,10.209 ; 139.45,10.229 169.296,10.229 174.5,5.025 180.699,5.025 v2(182.165,3.56)
I_LV_2: C54.1 J8.24 R76.2 R95.2 | length 255.1
  Top Layer w0.254: v2(113.082,58.836) 108.655,54.408 108.655,15.483 112.982,11.156 148.148,11.156 149.647,12.656 v2(162.956,12.656) 163.174,12.656 170.924,20.406 J8.24@174.354,20.406 ; R95.2@187.113,102.972 188.076,102.972 v2(188.125,103.021)
  Layer 2 w0.254: v2(162.956,12.656) 164.423,14.123 186.846,14.123 189,16.277 189,70.262 204.257,85.519 204.257,100.593 201.829,103.021 v2(188.125,103.021)
  Bottom Layer w0.254: C54.1@113.066,61.055 R76.2@113.066,59.791 113.082,59.774 v2(113.082,58.836)
"ISO 5V": C95.1 D10.1 R30.2 R37.2 U12.1 | length 9
  Top Layer w0.254: R30.2@27.852,118.732 R37.2@27.852,117.132 27.852,115.44 D10.1@27.847,115.436 27.847,114.664 28.361,114.151 C95.1@30.168,114.151 30.188,114.171 U12.1@32.568,114.171
LAG_EN_DRV: J20.7 U14.6 | length 60.6
  Bottom Layer w0.254: v2(60.143,7.335) 68.385,7.335 85.833,24.783 U14.6@113.477,24.783
LAG_EN_DRV_MCU: J8.95 U14.5 | length 92.1
  Top Layer w0.5: J8.95@177.754,52.406 180.213,52.406 v2(181.4,53.593)
  Layer 2 w0.254: v2(111.921,23.967) 113.981,23.967 124.314,34.3 169.975,34.3 180.644,44.969 180.644,52.837 v2(181.4,53.593)
  Bottom Layer w0.254: v2(111.921,23.967) 112.087,24.133 U14.5@113.477,24.133
LAG_EN_ISO_12V: J5.2 J20.5 U14.11 | length 173.6
  Top Layer w0.254: v2(117.83,23.483) 124.811,30.464 124.811,111.964 123.06,113.715 123.06,121.365 121.921,122.504 119.359,122.504 v2(118.28,121.425)
  Bottom Layer w0.254: v2(60.143,6.065) 68.09,6.065 82.35,20.325 114.672,20.325 v2(117.83,23.483) U14.11@119.377,23.483
LAG_EN_ISO_12V_MCU: J8.93 U14.13 | length 86.2
  Top Layer w0.5: J8.93@177.754,51.606 181.064,51.606 v2(181.51,52.052)
  Layer 2 w0.254: v2(117.719,22.015) 120.428,22.015 132.063,33.65 170.465,33.65 181.51,44.695 v2(181.51,52.052)
  Bottom Layer w0.254: v2(117.719,22.015) 117.887,22.183 U14.13@119.377,22.183
LAG_GaN_FAULT: J20.8 U4.1 | length 72.8
  Layer 3 w0.5: v2(56.457,7.335) 56.126,7.335 55.333,8.128 55.333,11.972 56.272,12.911 76.061,12.911 93.643,30.493 v2(114.195,30.493)
  Bottom Layer w0.254: v2(114.195,30.493) U4.1@115.197,30.493
LAG_HS_PWM: J8.53 J20.1 | length 172
  Top Layer w0.254: J8.53@177.754,32.406 182.189,32.406 186.425,28.17 186.425,5.981 v2(188.846,3.56)
  Layer 4 w0.254: v2(60.143,3.525) 64.65,3.525 70.725,9.6 87.2,9.6 96,0.8 186.086,0.8 v2(188.846,3.56)
LAG_HS_TEMP: J20.12 U1.15 U2.15 | length 94.1
  Bottom Layer w0.254: v2(56.457,9.875) 56.457,10.689 57.882,12.113 69.444,12.113 102.6,45.269 ; U2.15@115.087,44.769 114.195,44.769 113.695,45.269 102.6,45.269 ; U1.15@115.139,53.869 104.244,53.869 102.6,52.225 102.6,45.269
LAG_ISO_12V_L: J6.9 J11.3 pad.3@57.665,50.375 | length 101.2
  Layer 2 w0.5: v2(56.66,50.375) 56.66,51.105 57.158,51.603 66.653,51.603 110.638,95.587 110.638,112.363 109.285,113.715 109.285,116.391 110.482,117.588 110.482,118.606 109.977,119.111 v2(106.745,119.111)
LAG_ISO_-5V_L: J6.13 J11.5 pad.3@57.665,49.105 | length 98.8
  Layer 2 w0.5: v2(56.66,49.105) 56.043,49.105 55.475,49.673 55.475,51.603 56.397,52.525 66.143,52.525 109.746,96.128 109.746,111.742 108.402,113.086 108.402,117.082 v2(109.285,117.966)
LAG_LS_PWM: J8.55 J20.3 | length 181.3
  Top Layer w0.254: J8.55@177.754,33.206 183.258,33.206 187.575,28.889 187.575,6.193 v2(190.208,3.56)
  Layer 3 w0.254: v2(60.143,4.795) 62.82,4.795 68.9,10.875 89.35,10.875 98.325,1.9 135.432,1.9 143.893,10.362 157.938,10.362 163.079,5.221 189.664,5.221 190.208,4.676 v2(190.208,3.56)
LAG_LS_TEMP: J20.10 U1.11 U2.11 | length 89.7
  Top Layer w0.254: v2(56.457,8.605) 55.906,8.605 55.638,8.873 55.638,10.697 55.976,11.035 v2(62.085,11.035)
  Layer 2 w0.254: v2(110.547,50.993) 110.547,44.989 111.808,43.728 v2(111.808,42.269)
  Bottom Layer w0.254: v2(62.085,11.035) 69.264,11.035 100.498,42.269 v2(111.808,42.269) 113.695,42.269 114.195,42.769 U2.11@115.087,42.769 ; v2(110.547,50.993) 112.935,50.993 113.811,51.869 U1.11@115.139,51.869
LAG_OC_H: J20.9 U1.2 U2.2 | length 102.9
  Bottom Layer w0.254: J20.9@60.143,8.605 68.725,8.605 98.12,38 120.874,38 123.254,40.381 123.254,46.455 ; U2.2@118.087,44.769 119.313,44.769 120.89,46.346 123.146,46.346 123.254,46.455 ; U1.2@118.139,53.869 118.849,53.869 120.612,55.632 122.705,55.632 123.254,55.083 123.254,46.455
LAG_OC_L: J20.11 U1.4 U2.4 | length 87.7
  Layer 2 w0.254: v2(116.809,43.458) 116.809,50.977 118.801,52.97 v2(119.905,52.97)
  Bottom Layer w0.254: v2(60.143,9.875) 69.025,9.875 97.771,38.62 116.109,38.62 116.809,39.32 v2(116.809,43.458) 117.12,43.769 U2.4@118.087,43.769 ; U1.4@118.139,52.869 119.804,52.869 v2(119.905,52.97)
LAG_SW: pad.1@55.525,36.2 TP9.1 TP10.1
LEAD_EN_DRV: J12.7 U14.3 | length 82.6
  Layer 4 w0.254: v2(60.143,63.835) 88.915,63.835 106.6,46.15 106.6,25.19 108.715,23.075 v2(111.884,23.075)
  Bottom Layer w0.254: v2(111.884,23.075) 112.126,22.833 U14.3@113.477,22.833
LEAD_EN_DRV_MCU: J8.91 U14.2 | length 102.4
  Top Layer w0.5: 179.922,50.806 181.714,50.806 182.675,51.767 v2(182.675,56.2)
  Layer 2 w0.254: v2(111.933,22.015) 111.135,22.015 110.795,22.355 110.795,24.538 121.232,34.975 169.6,34.975 179.9,45.275 179.9,53.425 v2(182.675,56.2)
  Bottom Layer w0.254: v2(111.933,22.015) 112.101,22.183 U14.2@113.477,22.183
LEAD_EN_ISO_12V: J5.1 J12.5 U14.8 | length 192.7
  Top Layer w0.254: v2(117.01,118.725) 124.052,111.683 124.052,32.082 v2(117.663,25.693)
  Layer 4 w0.254: v2(60.143,62.565) 88.635,62.565 105.824,45.376 105.824,22.851 108.174,20.501 115.698,20.501 116.473,21.275 116.473,24.605 117.56,25.693 v2(117.663,25.693)
  Bottom Layer w0.254: v2(117.663,25.693) 117.923,25.433 U14.8@119.377,25.433
LEAD_EN_ISO_12V_MCU: J8.89 U14.10 | length 94
  Top Layer w0.254: J8.89@177.754,50.006 182.479,50.006 v2(183.427,50.954)
  Layer 2 w0.254: v2(117.627,24.605) 117.111,24.605 116.719,24.213 116.719,21.517 117.069,21.166 120.566,21.166 132.393,32.993 170.962,32.993 182.25,44.281 182.25,49.777 v2(183.427,50.954)
  Bottom Layer w0.254: v2@117.719,24.428 118.014,24.133 U14.10@119.377,24.133
LEAD_GaN_FAULT: J12.8 U4.2 | length 108.2
  Layer 4 w0.254: v2(56.457,63.835) 55.078,65.214 55.078,67.232 56.321,68.475 91.35,68.475 105.643,54.182 115.562,54.182 125.475,44.268 125.475,34.621 122.296,31.443 v2(114.195,31.443)
  Bottom Layer w0.254: v2(114.195,31.443) U4.2@115.197,31.443
LEAD_HS_PWM: J8.49 J12.1 | length 207.3
  Top Layer w0.254: J8.49@177.754,30.806 180.594,30.806 184.4,27 184.4,5.068 v2(185.908,3.56)
  Layer 4 w0.254: v2(60.143,60.025) 87.75,60.025 91.4,56.375 91.4,17.983 97.883,11.5 158.375,11.5 160.778,9.097 170.912,9.097 173.515,11.7 179.875,11.7 185.908,5.667 v2(185.908,3.56)