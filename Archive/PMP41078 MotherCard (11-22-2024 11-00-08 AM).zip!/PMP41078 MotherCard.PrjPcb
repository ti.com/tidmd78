# Altium project PMP41078 MotherCard.PrjPcb (part 2 of 2)

## Sheet V Sensor.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 4; SheetTotal: 6; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C41  Cap_F: 1µF  VDC_V: 25V  [0603S]  (hidden comment: CGA3E1X7R1E105K080AC)
C44  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C78  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C79  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C80  Cap_F: 1µF  VDC_V: 25V  [0603S]  (hidden comment: CGA3E1X7R1E105K080AC)
C81  VDC_V: 50V  ValueDisplayed: 2200pF  [0402]  (hidden comment: GCM155R71H222KA37D)
C82  VDC_V: 50V  ValueDisplayed: 2200pF  [0402]  (hidden comment: GCM155R71H222KA37D)
C83  Cap_F: 1µF  VDC_V: 25V  [0603S]  (hidden comment: CGA3E1X7R1E105K080AC)
C84  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C85  VDC_V: 50V  ValueDisplayed: 2200pF  [0402]  (hidden comment: GCM155R71H222KA37D)
C86  VDC_V: 50V  ValueDisplayed: 0.01uF  [0402]  (hidden comment: CGA2B3X7R1H103K050BB)
C87  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C88  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C90  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C91  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C92  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C93  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C95  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C96  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C97  VDC_V: 50V  ValueDisplayed: 0.01uF  [0402]  (hidden comment: CGA2B3X7R1H103K050BB)
C98  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C99  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C101  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C102  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
D10  value 4.7V  [SOD-523]  (hidden comment: EDZVFHT2R4.7B)
R30  ValueDisplayed: 2.00k  [0603]  (hidden comment: CRCW06032K00FKEA)
R37  ValueDisplayed: 2.00k  [0603]  (hidden comment: CRCW06032K00FKEA)
R42  ValueDisplayed: 47.5k  [0402]  (hidden comment: CRCW040247K5FKED)
R43  ValueDisplayed: 845k  [1206]  (hidden comment: ERJ-8ENF8453V)
R44  ValueDisplayed: 845k  [1206]  (hidden comment: ERJ-8ENF8453V)
R45  ValueDisplayed: 845k  [1206]  (hidden comment: ERJ-8ENF8453V)
R51  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R56  ValueDisplayed: 9.09k  [1206]  (hidden comment: CRCW12069K09FKEA)
R59  ValueDisplayed: 15.0k  [0402]  (hidden comment: CRCW040215K0FKED)
R60  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R61  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R65  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R66  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R68  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R69  ValueDisplayed: 15.0k  [0402]  (hidden comment: CRCW040215K0FKED)
R81  ValueDisplayed: 49.9  [0402]  (hidden comment: CRCW040249R9FKED)
R98  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R99  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R100  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R101  ValueDisplayed: 2.00k  [0402]  (hidden comment: ERJ-2RKF2001X)
R102  ValueDisplayed: 2.00k  [0402]  (hidden comment: ERJ-2RKF2001X)
R104  ValueDisplayed: 845k  [1206]  (hidden comment: ERJ-8ENF8453V)
R105  ValueDisplayed: 845k  [1206]  (hidden comment: ERJ-8ENF8453V)
R106  ValueDisplayed: 845k  [1206]  (hidden comment: ERJ-8ENF8453V)
R107  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R108  ValueDisplayed: 9.09k  [1206]  (hidden comment: CRCW12069K09FKEA)
R109  ValueDisplayed: 15.0k  [0402]  (hidden comment: CRCW040215K0FKED)
R112  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R113  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R116  ValueDisplayed: 15.0k  [0402]  (hidden comment: CRCW040215K0FKED)
R119  RMCF1206ZT0R00  [FP-RMCF1206ZT0R00_1206-MFG]  (value not drawn)
U9  AMC3311QDWERQ1  [DWE0016A-MFG]
U11  TLV9001QDBVRQ1  [DBV0005A-MFG]
U12  AMC1311BQDWVRQ1  [DWV0008A-MFG]
U13  TLV9001QDBVRQ1  [DBV0005A-MFG]

### Nets
3V3: C82.1 C83.1 C88.1 C96.1 C99.1 R42.1 U9.12(VDD) U11.5(V+) U12.8(VDD2) U13.5(V+)
AGND: C78.2 C82.2 C83.2 C88.2 C90.2 C91.2 C92.2 C93.2 C96.2 C99.2 C101.2 C102.2 R69.1 R101.1 R102.1 R116.1 U9.9(GND) U9.15(DCDC_GND) U11.2(V-) U12.5(GND2) U13.2(V-)
AGNDP: C41.2 C44.2 C79.2 C80.2 C81.2 C84.2 C85.2 C86.2 C95.2 C97.2 D10.2(A) R56.1 R108.1 R119.2 U9.2(DCDC_HGND) U9.7(HGND) U9.8(HGND) U12.3(SHTDN) U12.4(GND1)
ISO 5V: C95.1 D10.1(K) R30.2 R37.2 U12.1(VDD1)
PGND: R119.1
LEAD_ISO_12V_L: C41.1 C44.1 R30.1 R37.1
NC U4: U9.4(NC)
V_HV_1: C90.1 R68.1 R113.2
V_HV_2: C101.1 R68.2 R112.2
V_LV_1: C92.1 R99.1 R101.2
V_LV_2: C93.1 R100.1 R102.2
VBAT: R81.2 R98.2
VIN: R43.1
VMID: R104.1
VSNS_OUTN: R61.2 U9.10(OUTN)
VSNS_OUTN_2: R60.2 U12.6(VOUTN)
VSNS_OUTP: R66.2 U9.11(OUTP)
VSNS_OUTP_2: R65.2 U12.7(VOUTP)
NetC78_1: C78.1 U9.13(LDO_OUT) U9.16(DCDC_IN)
NetC79_1: C79.1 C80.1 C81.1 U9.1(DCDC_OUT) U9.3(HLDO_IN)
NetC84_1: C84.1 C85.1 U9.5(HLDO_OUT)
NetC86_1: C86.1 R51.1 U9.6(IN)
NetC87_1: C87.1 R59.1 R61.1 U13.4(IN-)
NetC87_2: C87.2 R59.2 R113.1 U13.1(OUT)
NetC91_1: C91.1 R66.1 R69.2 U13.3(IN+)
NetC97_1: C97.1 R107.1 U12.2(VIN)
NetC98_1: C98.1 R60.1 R109.1 U11.4(IN-)
NetC98_2: C98.2 R109.2 R112.1 U11.1(OUT)
NetC102_1: C102.1 R65.1 R116.2 U11.3(IN+)
NetR42_2: R42.2 U9.14(DIAG)
NetR43_2: R43.2 R44.1
NetR44_2: R44.2 R45.1
NetR45_2: R45.2 R51.2 R56.2
NetR81_1: R81.1 R99.2
NetR98_1: R98.1 R100.2
NetR104_2: R104.2 R105.1
NetR105_2: R105.2 R106.1
NetR106_2: R106.2 R107.2 R108.2

### Layout directives
net class PGND: 3V3, AGND, AGNDP, NC U4, PGND, V_HV_1, V_HV_2, VIN, VSNS_OUTN, VSNS_OUTP

### Notes on the sheet
- Primary Voltage: AMC3311 + TLV9001
- (near R30) Primary Voltage: AMC0311 + TLV9001
- DNP R30,R37,D10 in Havok Bias Card
- P2P, Use AMC0311-Q1
- PSFB: V_HV=15/10*1*(9.09/2544.1)*VBUS=0.00534VBUS
- VREF = 3V, Range: 562V max
- AMC0311: V_HV=15/10*1*(9.09/2544.1)*VBUS=0.00534VBUS
- SHB: V_HV=15/10*1*(4.70/2539.7)*VBUS=0.002775VBUS
- VREF = 3V, Range: 1080V max
- Secondary Voltage: Resistor Ladder
- V_LV=Vout / 12.05 * 2 = 0.166 * Vout
- V_LV=Vout / 12 * 2 = 0.1666 * Vout
- VREF = 3V, Range: 0 ~ 18.1V
- VREF = 3V, Range: 0 ~ 18V

### Library data of the parts
C41 C80 C83 = CMP-0076705-3: CAP, CERM, 1 µF, 25 V,+/- 10%, X7R, AEC-Q200 Grade 1, 0603; Manufacturer: TDK; SizeAreaWB_mm2: 4.68; SizeArea_mm2: 1.28; AEC Qualified: Y; AEC Category: Q200; Value: 1uF; TaMax_C: 125°C; SizeZ_mm: 1.0; AEC Grade: 1; Polarized: N; TaMin_C: -55°C; SizeY_mm: 0.8; U/M: EA; SizeX_mm: 1.6; Cap_Case: 1.6x0.8x0.8mm
C44 C78 C79 C84 C88 C95 C96 C99 = CMP-0080610-1: CAP, CERM, 0.1 µF, 25 V,+/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: TDK; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Qualified: Y; Cap_F: 100nF; AEC Category: Q200
C81 C82 C85 = CMP-0006357-2: CAP, CERM, 2200 pF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: MuRata; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 2200pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Qualified: Y; Cap_F: 2.2nF; AEC Category: Q200
C86 C97 = CMP-0006324-2: CAP, CERM, 0.01 uF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: TDK; TaMin_C: -55°C; ESR_ohm: 3.33065d; Polarized: N; SizeAreaWB_mm2: 3; Value1: 0.333065 ohm; U/M: EA; Value: 0.01uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Qualified: Y; Cap_F: 10nF; IRMS_A: 3.23373dA; AEC Category: Q200
C87 C90-C93 C98 C101 C102 = CMP-0085176-1: CAP, CERM, 220 pF, 16 V,+/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: Yageo; Value: 220pF; SizeZ_mm: 0.6; TaMin_C: -55°C; AEC Category: Q200; AEC Qualified: Y; SizeY_mm: 0.5; SizeAreaWB_mm2: 3; AEC Grade: 1; U/M: EA; TaMax_C: 125°C; Polarized: N
D10 = CMP-0005910-2: Diode, Zener, 4.7 V, 150 mW, AEC-Q101, SOD-523; Manufacturer: Rohm; Power_W: 150mW; SizeAreaWB_mm2: 5.13; Value1: 0.15W; U/M: EA; SizeZ_mm: 0.65; SizeX_mm: 1.7; SizeY_mm: 0.9; SizeArea_mm2: 1.53; AEC Qualified: Y; AEC Category: Q101
R30 R37 = CMP-0022268-4: RES, 2.00 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603; Manufacturer: Vishay-Dale; Power_W: 100mW; TempCo: 100 ppm/C; Value_Code: 2k00; Value: 2.00k; EIA_Code: E96; Res_ohm: 2k; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; Value2: 0.1W; SizeArea_mm2: 1.28; AEC Qualified: Y; VDC_V: 75V; AEC Category: Q200; AEC Grade: 0
R42 = CMP-0026395-2: RES, 47.5 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 47k5; Value: 47.5k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R43-R45 R104-R106 = CMP-0017741-3: RES, 845 k, 1%, 0.25 W, AEC-Q200 Grade 0, 1206; Manufacturer: Panasonic; Power_W: 250mW; TempCo: 100 ppm/C; Value: 845k; EIA_Code: E96; SizeX_mm: 3.2; SizeY_mm: 1.6; SizeZ_mm: 1.35; Value2: 0.25W; SizeArea_mm2: 5.12; AEC Qualified: Y; VDC_V: 200V; AEC Category: Q200; AEC Grade: 0; SizeAreaWB_mm2: 10.92
R51 R68 R98 R107 = CMP-0026822-3: RES, 0, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200
R56 R108 = CMP-0017234-3: RES, 9.09 k, 1%, 0.25 W, AEC-Q200 Grade 0, 1206; Manufacturer: Vishay-Dale; Power_W: 250mW; TempCo: 100 ppm/C; Value_Code: 9k09; Value: 9.09k; EIA_Code: E96; SizeX_mm: 3.2; SizeY_mm: 1.6; SizeZ_mm: 1.35; Value2: 0.25W; SizeArea_mm2: 5.12; AEC Qualified: Y; VDC_V: 200V; AEC Category: Q200; AEC Grade: 0
R59 R69 R109 R116 = CMP-0026027-3: RES, 15.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 15k0; Value: 15.0k; EIA_Code: E96; Res_ohm: 15k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R60 R61 R65 R66 R99 R100 = CMP-0026748-1: RES, 10.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: KOA Speer; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; U/M: EA; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R81 = CMP-0026404-2: RES, 49.9, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 49R9; Value: 49.9; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R101 R102 = CMP-0026676-1: RES, 2.00 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 100 ppm/C; Value_Code: 2k00; U/M: EA; Value: 2.00k; EIA_Code: E96; Res_ohm: 2k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R112 R113 = CMP-0026764-1: RES, 10.0, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Stackpole Electronics Inc; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10R0; U/M: EA; Value: 10.0; EIA_Code: E96; Res_ohm: 10; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; AEC Grade: 0; AEC Category: Q200
R119 = CMP-0093609-1: 0Ω ±0 0.25W 1206 Thick Film Chip Resistor AEC-Q200 compliant; Manufacturer: Stackpole Electronics; Res_ohm: 0; AEC Qualified: Yes; Value: 0; VDC_V: 200V; AEC Grade: Grade 0; Power_W: 250mW; SizeZ_mm: 0.7mm
U9 = CMP-0121212-1: Automotive, 0 to 2-V input, precision reinforced isolated amplifier with integrated DC/DC converter 16-SOIC -40 to 125; Manufacturer: Texas Instruments; SizeZ_mm: 2.65mm; AEC Qualified: Yes; AEC Grade: Grade 1; Bandwidth: 275kHz; Input Bias Current: 0.0035uA; Input Offset Voltage: 0.1mV; Max Supply Voltage: 5.5V; Min Supply Voltage: 3V; Nominal Supply Current: 28.5-36.5mA; Number Of Channels: 1; Output Current Per Channel: 14mA; Response Time: 0.6ms; Standoff Height: 0.1mm; TaMax_C: +125°C; TaMin_C: -40°C; TJmax_C: +150°C; Voltage Gain: 0.001V/mV
U11 U13 = CMP-0120546-1: Automotive, single-channel, 5.5-V 1-MHz rail-to-rail input and output operational amplifier 5-SOT-23 -40 to 125; Manufacturer: Texas Instruments; SizeZ_mm: 1.45mm; AEC Qualified: Yes; AEC Grade: Grade 1; Gain Bandwidth: 1MHz; Input Bias Current: 0.000005uA; Input Offset Voltage: 0.4mV; Max Dual Supply Voltage: 2.75V; Max Supply Voltage: 5.5V; Min Dual Supply Voltage: 900mV; Min Supply Voltage: 1.8V; Nominal Supply Current: 60uA; Number Of Channels: 1; Output Current Per Channel: 40mA; Response Time: 3us; Standoff Height: 0mm; TaMax_C: +125°C; TaMin_C: -40°C; TJmax_C: +150°C; Voltage Gain: 130dB
U12 = CMP-0090465-1: Automotive 2-V input, reinforced isolated amplifier with high CMTI for voltage sensing 8-SOIC -40 to 125; Manufacturer: Texas Instruments; Input Offset Voltage: -1.1mV; Response Time: 50us; Standoff Height: 0.36mm; Nominal Supply Current: 5.3-7.1mA; AEC Grade: Grade 1; Number Of Channels: 1; TJmax_C: +150°C; AEC Qualified: Yes; Max Supply Voltage: 5.5V; SizeZ_mm: 2.8mm; Input Bias Current: 0.0035uA; TaMax_C: +125°C; TaMin_C: -40°C; Output Current Per Channel: 13mA; Min Supply Voltage: 3V; Bandwidth: 275kHz

## Sheet I Sensor.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Forest Fu; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 5; SheetTotal: 6; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C24  VDC_V: 50V  ValueDisplayed: 10pF  [0402]  (hidden comment: 04025U100CAT2A)
C29  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C30  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C35  VDC_V: 50V  ValueDisplayed: 10pF  [0402]  (hidden comment: 04025U100CAT2A)
C42  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C45  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C51  VDC_V: 50V  ValueDisplayed: 2200pF  [0402]  (hidden comment: GCM155R71H222KA37D)
C53  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C54  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C55  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C75  Cap_F: 1µF  VDC_V: 25V  [0603S]  (hidden comment: CGA3E1X7R1E105K080AC)
C76  VDC_V: 25V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: CGA2B3X7R1E104K050BB)
C77  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C94  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C100  VDC_V: 50V  ValueDisplayed: 2200pF  [0402]  (hidden comment: GCM155R71H222KA37D)
C103  ValueDisplayed: 220pF  VDC_V: 16V  [0402]  (hidden comment: AC0402KRX7R7BB221)
C104  VDC_V: 50V  ValueDisplayed: 2200pF  [0402]  (hidden comment: GCM155R71H222KA37D)
D6  MBR130T3G  [FP-MBR130T3G_SOD123-MFG]  (value not drawn)
D7  MBR130T3G  [FP-MBR130T3G_SOD123-MFG]  (value not drawn)
D8  MBR130T3G  [FP-MBR130T3G_SOD123-MFG]  (value not drawn)
D9  MBR130T3G  [FP-MBR130T3G_SOD123-MFG]  (value not drawn)
J14  0734151471  [Molex_0734151471]  (value not drawn)
J15  0734151471  [Molex_0734151471]  (value not drawn)
J16  0734151471  [Molex_0734151471]  (value not drawn)
L1  BLM15AX601SN1D  [0402]
R24  ValueDisplayed: 2.00k  [0402]  (hidden comment: ERJ-2RKF2001X)
R25  ValueDisplayed: 1.00k  [0402]  (hidden comment: CRCW04021K00FKED)
R27  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R28  ValueDisplayed: 15.0  [1206]  (hidden comment: CRCW120615R0FKEA)
R29  ValueDisplayed: 15.0  [1206]  (hidden comment: CRCW120615R0FKEA)
R31  ValueDisplayed: 1.00k  [0402]  (hidden comment: CRCW04021K00FKED)
R32  ValueDisplayed: 2.00k  [0402]  (hidden comment: ERJ-2RKF2001X)
R38  ValueDisplayed: 2.00k  [0603]  (hidden comment: CRCW06032K00FKEA)
R39  ValueDisplayed: 15.0  [1206]  (hidden comment: CRCW120615R0FKEA)
R40  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R41  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R46  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R47  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R48  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R49  ValueDisplayed: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R52  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R54  ValueDisplayed: 7.50k  [0402]  (hidden comment: ERA-2AEB752X)
R58  ValueDisplayed: 15.0k  [0402]  (hidden comment: CRCW040215K0FKED)
R62  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R67  ValueDisplayed: 1.00k  [0402]  (hidden comment: CRCW04021K00FKED)
R73  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R74  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R75  ValueDisplayed: 15.0k  [0402]  (hidden comment: CRCW040215K0FKED)
R76  ValueDisplayed: 10.0  [0402]  (hidden comment: RMCF0402JT10R0)
R78  ValueDisplayed: 7.50k  [0402]  (hidden comment: ERA-2AEB752X)
R79  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R103  ValueDisplayed: 10.0k  [0402]  (hidden comment: RK73H1ETTP1002F)
R110  ValueDisplayed: 100  [0402]  (hidden comment: CRCW0402100RFKED)
R111  ValueDisplayed: 3.65k  [0402]  (hidden comment: CRCW04023K65FKED)
R114  ValueDisplayed: 1.00k  [0402]  (hidden comment: CRCW04021K00FKED)
R115  ValueDisplayed: 100  [0402]  (hidden comment: CRCW0402100RFKED)
T1  CST2010-100LB  [CST2010]
U5  TLV365QDBVRQ1  [DBV0005A-MFG]
U6  TMCS1133B2QDVGR  [DVG0010A-MFG]
U7  INA296A4QDDFRQ1  [DDF0008A-MFG]
U10  INA225AQDGKRQ1  [DGK0008A_N]

### Nets
3V3: C29.1 C42.1 C53.1 C75.1 C76.1 L1.1 R41.1 R46.1 R58.2 R78.2 R79.2 R103.2 R111.1 U5.5(V+) U7.6(Vs) U10.3(VS)
AGND: C29.2 C30.2 C35.2 C42.2 C51.2 C53.2 C54.2 C75.2 C76.2 C77.2 C94.2 C100.2 C103.2 C104.2 J14.2 J14.3 J14.4 J14.5 J15.2 J15.3 J15.4 J15.5 J16.2 J16.3 J16.4 J16.5 R32.1 R48.2 R49.1 R54.1 R75.1 R114.1 U5.2(V-) U6.3(GND) U7.2(GND) U10.2(GND)
DGND: R73.1 R74.1
GS0: R46.2 R49.2 U10.5(GS0)
GS1: R41.2 R48.1 U10.6(GS1)
I_HV_1: C77.1 J15.1 R40.2
I_HV_2: C30.1 J14.1 R27.2
I_HV_FAULT: C104.1 R115.2
I_HV_FILTER: C51.1 R67.2
I_HV_OC: C100.1 R110.2
I_LV_1: C94.1 J16.1 R62.2
I_LV_2: C54.1 R76.2
LEAD_SW_R: T1.12
VBAT: R52.1
VBUS: U6.2(IN-)
VIN: U6.1(IN+)
VOUT: R47.1
VPRI+: T1.11
NetC24_1: C24.1 R24.2 R27.1 R67.1 U5.1(VOUT)
NetC24_2: C24.2 R24.1 R25.2 U5.4(-IN)
NetC35_1: C35.1 R31.2 R32.2 U5.3(+IN)
NetC45_1: C45.1 R47.2 U7.8(IN+)
NetC45_2: C45.2 R52.2 U7.1(IN-)
NetC55_1: C55.1 R73.2 U10.1(IN+)
NetC55_2: C55.2 R74.2 U10.8(IN-)
NetC103_1: C103.1 R111.2 R114.2 U6.8(VOC)
NetD6_1: D6.1(CATHODE) D8.2(ANODE) R38.2 T1.4
NetD6_2: D6.2(ANODE) D7.2(ANODE) R25.1 R28.2 R29.2 R39.2
NetD7_1: D7.1(CATHODE) D9.2(ANODE) R38.1 T1.2
NetD8_1: D8.1(CATHODE) D9.1(CATHODE) R28.1 R29.1 R31.1 R39.1
NetL1_2: L1.2 U6.9(VS) U6.10(VS)
NetR40_1: R40.1 U6.6(VOUT)
NetR54_2: R54.2 R58.1 U7.3(REF2) U7.7(REF1)
NetR62_1: R62.1 U7.5(OUT)
NetR75_2: R75.2 R78.1 U10.7(REF)
NetR76_1: R76.1 U10.4(OUT)
NetR79_1: R79.1 R110.1 U6.7(~{OC})
NetR103_1: R103.1 R115.1 U6.4(~{FAULT})

Not connected (* = marked no-connect by the designer): T1 1(NC) 3(NC) 5(NC) 6(NC) 7(NC) 8(NC) 9(NC) 10(NC); U6 5(NC)*; U7 4(NC)*

### Layout directives
net class VHV: LEAD_SW_R

### Notes on the sheet
- Primary Input Current: TMCS1133
- (near C24) Primary Input Current: Current transformer + TLV365
- Close to DSP
- (near D8) I_HV=(¦Ipri / 100¦ * 5) * 2 = 0.1 * ¦Ipri¦
- VREF = 3V, Range: -30 ~30A
- OC = 3.3 / 4.65 * 1000 * 2.5 / 50 = 35A
- I_LV = Iout * 0.05 / 1000 * 100 + 1.1 = 1.1 + 0.005 * Iout
- Rsense = 0.05 mohm
- (near C42) Secondary Inductor Current: INA296
- I_HV = - Ipri * 50 /1000 + 1.65 = 1.65 - 0.05 * Ipri
- VREF = 3V, Range: -27 ~33A
- VREF = 3V, Range: -220 ~380A
- (near R62) Close to DSP
- Secondary Output Current: INA225
- (near R73) DGND close to choke
- (near U10) 250kHz
- Copper Bar
- (near R74) DGND close to output terminal
- I_LV= - (Iout * Rcopper) * 100 + 15 / 22.5 * 3.3 = 2.2 - 0.004 * Isec
- Rcopper = p * L / S ~= 1.7e-8 * 70e-3 / 30e-6 = 0.04 mohm
- VREF = 3V, Range: -200 ~550A

### Library data of the parts
C24 C35 = CMP-0064911-2: CAP, CERM, 10 pF, 50 V,+/- 2.5%, C0G/NP0, AEC-Q200 Grade 1, 0402; Manufacturer: AVX; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 10pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Qualified: Y; AEC Category: Q200
C29 C42 C53 C76 = CMP-0080610-1: as C44 on sheet V Sensor
C30 C45 C54 C55 C77 C94 C103 = CMP-0085176-1: as C87 on sheet V Sensor
C51 C100 C104 = CMP-0006357-2: as C81 on sheet V Sensor
C75 = CMP-0076705-3: as C41 on sheet V Sensor
D6-D9 = CMP-0094495-1: Diode Schottky 30 V 1A Surface Mount SOD-123; Manufacturer: onsemi; Import Ts: 1521868375; Standoff Height: 0mm; Vr_V: 30V; SizeZ_mm: 1.35mm; Peak Reverse Current: 60uA; TJmax_C: 125°C; Ciiva Ids: 822455; Max Surge Forward Current: 5.5A; AEC Qualified: No
J14-J16 = CMP-0055255-2: MMCX JACK, 50 Ohm, Gold, TH; Manufacturer: Molex; CT: FALSE; Gender: Female
L1 = CMP-0003317-1: Ferrite Bead, 600 ohm @ 100 MHz, 0.5 A, 0402; Manufacturer: MuRata; ZTyp@100MHz_Ohm: 600; SizeAreaWB_mm2: 3; DCR_ohm: 3.4d; Value1: 0.34 ohm; Value: 600 ohm; Imax_A: 5dA; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Value2: 0.5A
R24 R32 = CMP-0026676-1: as R101 on sheet V Sensor
R25 R31 R67 R114 = CMP-0026071-3: RES, 1.00 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 1k00; Value: 1.00k; EIA_Code: E96; Res_ohm: 1k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R27 R40 R47 R52 R62 R73 R74 R76 = CMP-0026764-1: as R112 on sheet V Sensor
R28 R29 R39 = CMP-0016648-3: RES, 15.0, 1%, 0.25 W, AEC-Q200 Grade 0, 1206; Manufacturer: Vishay-Dale; Power_W: 250mW; TempCo: 100 ppm/C; Value_Code: 15R0; Value: 15.0; EIA_Code: E96; Res_ohm: 15; SizeX_mm: 3.2; SizeY_mm: 1.6; SizeZ_mm: 1.35; Value2: 0.25W; SizeArea_mm2: 5.12; AEC Qualified: Y; VDC_V: 200V; AEC Category: Q200; AEC Grade: 0
R38 = CMP-0022268-4: as R30 on sheet V Sensor
R41 R46 R48 R49 = CMP-0026822-3: as R51 on sheet V Sensor
R54 R78 = CMP-0026786-1: RES, 7.50 k, 0.1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 63mW; TempCo: 25 ppm/C; Value_Code: 7k50; U/M: EA; Value: 7.50k; EIA_Code: E192; Res_ohm: 7.5k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R58 R75 = CMP-0026027-3: as R59 on sheet V Sensor
R79 R103 = CMP-0026748-1: as R60 on sheet V Sensor
R110 R115 = CMP-0025951-3: RES, 100, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 100R; Value: 100; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R111 = CMP-0026337-2: RES, 3.65 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 3k65; Value: 3.65k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
T1 = CMP-0085494-1: Current Sense Transformer, 8.5 mH, 254 Vµs, 40 A, AEC-Q200 Grade 1, SMT; Manufacturer: Coilcraft; SizeArea_mm2: 289.6905; Lp: 8500; SizeX_mm: 19.91; Ns1toNp: 100; SizeY_mm: 14.55; SizeAreaWB_mm2: 362.6105; AEC Grade: 1; Value: 8.5mH; Rsec1_ohm: 1.45; SizeZ_mm: 10.5; DCR_ohm: 360µ; AEC Category: Q200; AEC Qualified: Y
U5 = CMP-0121215-2: Automotive 50-MHz single-supply operational amplifier with rail-to-rail input and output 5-SOT-23 -40 to 125; Manufacturer: Texas Instruments; SizeZ_mm: 1.45mm; AEC Qualified: Yes; AEC Grade: Grade 1; Gain Bandwidth: 50MHz; Input Bias Current: 0.000005uA; Input Offset Voltage: 0.4mV; Max Supply Voltage: 5.5V; Min Supply Voltage: 2.2V; Nominal Supply Current: 4.6mA; Number Of Channels: 1; Output Current Per Channel: 85mA; Response Time: 0.2us; Standoff Height: 0mm; TaMax_C: +125°C; TaMin_C: -40°C; TJmax_C: +150°C; Voltage Gain: 120dB; AEC Category: Q200; CompType: IC
U6 = CMP-0097985-1: Manufacturer: Texas Instruments; SizeZ_mm: 2.65mm; Standoff Height: 0.1mm
U7 = CMP-0121413-1: AEC-Q100, -5-V to 110-V, bidirectional, 1.1-MHz 8-V/µs ultraprecise current sense amplifier; Manufacturer: Texas Instruments; SizeZ_mm: 1.1mm; AEC Qualified: Yes; AEC Grade: Grade 1; Bandwidth: 1.1MHz; Input Bias Current: 35uA; Input Offset Voltage: 0.003mV; Max Supply Voltage: 20V; Min Supply Voltage: 2.7V; Nominal Supply Current: 2.5mA; Number Of Channels: 1; Response Time: 1.5us; Standoff Height: 0mm; TaMax_C: +125°C; TaMin_C: -40°C; TJmax_C: +150°C; Voltage Gain: 0.1V/mV
U10 = CMP-0065433-2: Automotive, 36-V Prog. Gain, Bi-Directional, Zero-Drift, High-Speed Voltage Out Current Sense Amp, DGK0008A (VSSOP-8); Alternate Manufacturer: Texas Instruments; SizeAreaWB_mm2: 23.6; SizeZ_mm: 1.1; SizeX_mm: 4.9; SizeY_mm: 3; SizeArea_mm2: 14.7; CompType: IC; AEC Category: Q200; AEC Qualified: Y

## Sheet DCDC MotherCard_Hardware.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Forest Fu; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 3; Revision: Use project parameter SCH_Rev; SheetNumber: 5; SheetTotal: 5; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
!PCB1  Printed Circuit Board  (value not drawn)  (mechanical)
LBL1  THT-14-423-10  Note: Size: 0.65" x 0.20 "  [Label_650x200]
Logo1  CE Mark  [CE_Mark_5mm]  (no BOM)
LOGO2  DANGER HIGH VOLTAGE  [IEC_HighVoltage_Small]  (no BOM)
Logo3  FCC disclaimer  [FCC_disclaimer]  (no BOM)
Logo4  WEEE logo  [WEEE_Minimum]  (no BOM)
LOGO5  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
LOGO6  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
ZZ1  This Assembly Note is for PCB labels only  [AssemblyNoteLabel]  (no BOM)
ZZ2  These assemblies are ESD sensitive, ESD precautions shall be observed.  [AssemblyNote]  (no BOM)
ZZ3  These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable.  [AssemblyNote]  (no BOM)
ZZ4  These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified.  [AssemblyNote]  (no BOM)

### Notes on the sheet
- Variant
- Variant/Label Table
- Label Text
- 001
- 002
- ChangeMe!

### Library data of the parts
!PCB1 = CMP-0003618-2: Manufacturer: Any; PartNumber: Mother Board
LBL1 = CMP-0003625-1: Thermal Transfer Printable Labels, 0.650" W x 0.200" H - 10,000 per roll; Manufacturer: Brady; CompType: Label
Logo1 = CMP-0074844-1: SymbolCreator: a0412235
LOGO2 = CMP-0074835-1: IEC 61010-1 High Voltage Warning; SymbolCreator: a0412235
Logo3 = CMP-0074847-1: FCC_disclaimer; Library Reference: Logo
Logo4 = CMP-0074769-1
LOGO5 LOGO6 = CMP-0074837-1: IEC 61010-1 Hot Surface Warning; SymbolCreator: a0412235
ZZ1 = CMP-0003616-3
ZZ2 = CMP-0077236-1
ZZ3 = CMP-0077237-1
ZZ4 = CMP-0077238-1

## Sheet PowerTree.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Forest Fu; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 1; SheetTotal: 5; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Notes on the sheet
- Board Config
- Power Tree
- FuSa
- Diagram
- Connection

## Nets that join several sheets
3V3: Controller (16 pins), V Sensor (10 pins), I Sensor (16 pins)
5V0: PowerStage (J2.5 J12.2 J17.4 J20.2), Controller (7 pins)
AGND: PowerStage (15 pins), Controller (54 pins), V Sensor (21 pins), I Sensor (36 pins)
AGNDP: PowerStage (J6.3 J7.4 J7.6 R20.2), V Sensor (19 pins)
BIAS_VIN: PowerStage (5 pins), Controller (C52.1 R92.2 R97.2 U3.10)
DGND: PowerStage (38 pins), Controller (R11.1), I Sensor (R73.1 R74.1)
PGND: PowerStage (19 pins), V Sensor (R119.1)
ACL1_PWM: PowerStage (J17.1), Controller (J8.58)
ACL2_PWM: PowerStage (J17.2), Controller (J8.60)
EN_5V0: PowerStage (J5.4), Controller (J8.72)
EN_12V: PowerStage (J5.3), Controller (J8.74)
EN_ACL: PowerStage (J17.8), Controller (J8.70)
EN_SR: PowerStage (J17.7), Controller (J8.68)
I_HV_1: Controller (J8.11), I Sensor (C77.1 J15.1 R40.2)
I_HV_2: Controller (J8.12), I Sensor (C30.1 J14.1 R27.2)
I_HV_FAULT: Controller (J8.110), I Sensor (C104.1 R115.2)
I_HV_FILTER: Controller (J8.28), I Sensor (C51.1 R67.2)
I_HV_OC: Controller (J8.108), I Sensor (C100.1 R110.2)
I_LV_1: Controller (J8.21 R91.2), I Sensor (C94.1 J16.1 R62.2)
I_LV_2: Controller (J8.24 R95.2), I Sensor (C54.1 R76.2)
LAG_EN_DRV: PowerStage (J20.7), Controller (U14.6)
LAG_EN_ISO_12V: PowerStage (J5.2 J20.5), Controller (U14.11)
LAG_GaN_FAULT: PowerStage (J20.8), Controller (U4.1)
LAG_HS_PWM: PowerStage (J20.1), Controller (J8.53)
LAG_HS_TEMP: PowerStage (J20.12), Controller (U1.15 U2.15)
LAG_LS_PWM: PowerStage (J20.3), Controller (J8.55)
LAG_LS_TEMP: PowerStage (J20.10), Controller (U1.11 U2.11)
LAG_OC_H: PowerStage (J20.9), Controller (U1.2 U2.2)
LAG_OC_L: PowerStage (J20.11), Controller (U1.4 U2.4)
LEAD_EN_DRV: PowerStage (J12.7), Controller (U14.3)
LEAD_EN_ISO_12V: PowerStage (J5.1 J12.5), Controller (U14.8)
LEAD_GaN_FAULT: PowerStage (J12.8), Controller (U4.2)
LEAD_HS_PWM: PowerStage (J12.1), Controller (J8.49)
LEAD_HS_TEMP: PowerStage (J12.12), Controller (U1.12 U2.12)
LEAD_ISO_12V_L: PowerStage (J6.1 J7.3), V Sensor (C41.1 C44.1 R30.1 R37.1)
LEAD_LS_PWM: PowerStage (J12.3), Controller (J8.51)
LEAD_LS_TEMP: PowerStage (J12.10), Controller (U1.14 U2.14)
LEAD_OC_H: PowerStage (J12.9), Controller (U1.1 U2.1)
LEAD_OC_L: PowerStage (J12.11), Controller (U1.5 U2.5)
LEAD_SW_R: PowerStage (8 pins), I Sensor (T1.12)
SR1_HS_PWM: PowerStage (J17.9), Controller (J8.50)
SR1_LS_PWM: PowerStage (J17.10), Controller (J8.52)
SR2_HS_PWM: PowerStage (J17.11), Controller (J8.54)
SR2_LS_PWM: PowerStage (J17.12), Controller (J8.56)
T_LV_1: PowerStage (J17.13), Controller (J8.30)
T_LV_2: PowerStage (J17.14), Controller (J8.20)
V_HV_1: Controller (J8.25), V Sensor (C90.1 R68.1 R113.2)
V_HV_2: Controller (J8.26), V Sensor (C101.1 R68.2 R112.2)
V_LV_1: Controller (J8.15), V Sensor (C92.1 R99.1 R101.2)
V_LV_2: Controller (J8.18), V Sensor (C93.1 R100.1 R102.2)
VBAT: PowerStage (42 pins), V Sensor (R81.2 R98.2), I Sensor (R52.1)
VBUS: PowerStage (6 pins), I Sensor (U6.2)
VIN: PowerStage (13 pins), V Sensor (R43.1), I Sensor (U6.1)
VMID: PowerStage (10 pins), V Sensor (R104.1)
VOUT: PowerStage (J13.1 J13.3 L3.1), I Sensor (R47.1)
VPRI+: PowerStage (T2.1), I Sensor (T1.11)

## Assembly variants
PMP41078 PSFB version: not fitted J10 L2 R4 R5 R6 R7 R10 R12 R13 R16 R26 R41 R49 R118 R129 R132 R133
SHB version: not fitted J10 L2 R1 R10 R12 R13 R15 R19 R20 R41 R49 R117 R120 R121 R122 R123 R124 R126 R127 R128